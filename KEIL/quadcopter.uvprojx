# Keil uVision project quadcopter.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: quadcopter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER
  c include: ..\uC-LIB;..\uC-CPU;..\APP\inc;..\BSP\inc;..\CORE\inc;..\LIB\inc;..\HARDWARE\inc;..\uCOS-II\CONFIG;..\uCOS-II\CORE;..\uCOS-II\PORT;..\DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ../APP/src/: main.c data_transfer.c data_fusion.c ahrs.c pid.c quad_pid.c
  group BSP
    ../BSP/src/: system_stm32f4xx.c startup_stm32f401xx.s
  group CORE
    ../CORE/src/: i2c.c stm32f4xx_it.c sysTick.c tim.c USART.c si2c.c
  group HARDWARE
    ../HARDWARE/src/: codetab.c hm10.c hmc5883l.c LED.c motor.c mpu6050.c oled.c receiver.c
  group LIB
    ../LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uCOS-II
    ../uCOS-II/CORE/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../uCOS-II/PORT/: os_cpu_c.c os_cpu_a.asm
  group DMP
    ../DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
